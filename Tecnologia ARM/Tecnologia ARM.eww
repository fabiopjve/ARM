<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\exemplo2_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_10.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_11.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_12.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_13.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_14.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_15.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_16.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_17.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_18.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_19.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_20.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_21.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_22.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_5.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_6.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_7.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_8.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_9.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo5_usb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo6_1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\exemplo6_4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


