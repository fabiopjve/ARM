# IAR project exemplo5_usb.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: STR711 ST STR711
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: Z:\Livro ARM7\arquivos\str71x_lnk.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: ex_usb_volume.c MEU_STR71x_init.s
